# Keil uVision project quadcopter.uvproj, settings and files
target Quadcopter (ARM-ADS)
  device: LPC1114/202 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10000FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: blinky
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x1000
  group Startup
    ./: startup_LPC11xx.s system_LPC11xx.c
  group Quadcopter
    ./: main.c cpu_lpc1000.c debug_printf.c i2c.c kalman.c motors.c mpu.c pid.c retarget.c ssp.c system_LPC11xx.c timer32.c uart.c
